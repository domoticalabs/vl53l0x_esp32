## Kconfig
```kconfig
menu "VL53L0X API"

    config VL53L0X_I2C_ADDR
        hex "i2c address"
        default 0x29
        help
            set i2c address (default : 0x29)

endmenu
```
